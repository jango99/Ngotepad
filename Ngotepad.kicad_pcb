# Repository jango99/Ngotepad

File README.md:

# Ngotepad
Introducing the Ngotepad (pronounced "notepad"), a 4x2 macropad that supports two rotary encoders.

Keyboard Maintainer: [Jason Ngo/jango99](https://github.com/jango99)

Hardware Supported: Elite-C, atmega32u4 based MCU

Hardware Availability: [Open Source](https://github.com/jango99/Ngotepad/tree/master/Gerbers)

## KiCad design Ngotepad.kicad_pcb

Board: 2 copper layers, 66.7 x 85.7 mm, 11 parts (0 on the bottom side), 15 nets.

Parts:
SW_A1, SW_A2: MX_LED; MXOnly-1U
SW_B1, SW_B2: MX_LED; MXOnly-1U
SW_C1, SW_C2: MX_LED; MXOnly-1U
SW_D1, SW_D2: MX_LED; MXOnly-1U
SW_E1, SW_E2: Rotary_Encoder_Switch; RotaryEncoder_EC11
U1: Elite-C

Connections:
Enc1A: SW_E1.A, U1.25
Enc1B: SW_E1.B, U1.26
Enc2A: SW_E2.A, U1.28
Enc2B: SW_E2.B, U1.29
GND: SW_A1.2, SW_A2.2, SW_B1.2, SW_B2.2, SW_C1.2, SW_C2.2, SW_D1.2, SW_D2.2, SW_E1.C, SW_E1.S1, SW_E2.C, SW_E2.S1, U1.3, U1.4, U1.23
SWA1: SW_A1.1, U1.6
SWA2: SW_A2.1, U1.5
SWB1: SW_B1.1, U1.7
SWB2: SW_B2.1, U1.8
SWC1: SW_C1.1, U1.9
SWC2: SW_C2.1, U1.10
SWC3: SW_E1.S2, U1.13
SWD1: SW_D1.1, U1.11
SWD2: SW_D2.1, U1.12
SWD3: SW_E2.S2, U1.14

## Commit log

2020-02-16 Added Ngotepad Assets
2020-02-18 Updated Gerbers
2020-02-19 Organized files
2020-03-02 updated direction
